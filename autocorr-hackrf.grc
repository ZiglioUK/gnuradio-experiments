options:
  parameters:
    generate_options: qt_gui
    id: auto_corr
    output_language: python
    title: auto_corr
  states: {}

blocks:
- name: decimate
  id: variable
  parameters:
    value: '200'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1575420000'
  states: {}
- name: integrate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8E6
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/(2*decimate)
    decim: decimate
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/(10*decimate)
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0,bias=1"'
    bb_gain0: '40'
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate/decimate/2
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    ymax: '-60'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimate/2
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    update_time: '0.1'
  states: {}

connections:
- [blocks_deinterleave_0, '0', blocks_multiply_xx_0, '0']
- [blocks_deinterleave_0, '1', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0, '0', blocks_deinterleave_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
