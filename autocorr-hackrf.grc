options:
  parameters:
    generate_options: qt_gui
    id: auto_corr
    output_language: python
    title: auto_corr
  states: {}

blocks:
- name: ch_f
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate/decimate/2'
    step: '100'
    stop: samp_rate/decimate/2
    value: '0'
  states: {}
- name: decimate
  id: variable
  parameters:
    value: '200'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1575420000'
  states: {}
- name: integrate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8E6
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '0.3'
    min_freq: '-0.3'
    w: '50'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: BPF
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/decimate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-ch_f'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/decimate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/(2*decimate)
    decim: decimate
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/(10*decimate)
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '150'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/decimate
    type: fir_filter_ccf
    width: '15'
    win: window.WIN_BLACKMAN
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0,bias=0"'
    bb_gain0: '40'
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate/decimate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    ymax: '-80'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate/decimate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"LP"'
    type: complex
    ymax: '-90'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate/decimate
    type: complex
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', qtgui_const_sink_x_0, '0']
- [analog_pll_carriertracking_cc_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_1, '0']
- [blocks_multiply_xx_1_0, '0', low_pass_filter_1, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_xx_0, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_xx_0, '1']
- [low_pass_filter_0, '0', blocks_multiply_xx_1, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_1_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_1, '0', analog_pll_carriertracking_cc_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
