options:
  parameters:
    generate_options: qt_gui
    id: auto_corr
    output_language: python
    title: auto_corr
  states: {}

blocks:
- name: fft_sz
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1575420000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048E6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl_tcp=192.168.56.1:1234,bias=1"'
    bb_gain0: '40'
    freq0: freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_auto_correlator_sink_0
  id: qtgui_auto_correlator_sink
  parameters:
    fac_decimation: '10'
    fac_size: '20480'
    sampRate: samp_rate
    yMax: '0'
    yMin: '-90'
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_auto_correlator_sink_0, '0']
- [osmosdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
