options:
  parameters:
    generate_options: qt_gui
    id: auto_corr
    output_language: python
    title: auto_corr
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '1575420000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048E6
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0,bias=1"'
    bb_gain0: '30'
    freq0: freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_auto_correlator_sink_0
  id: qtgui_auto_correlator_sink
  parameters:
    autoScale: 'False'
    fac_decimation: '10'
    fac_size: '20480'
    sampRate: samp_rate
    yMax: '10'
    yMin: '-60'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: '15000'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '15000'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    update_time: '0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '1'
    type: ccc
  states: {}

connections:
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '1']
- [osmosdr_source_0, '0', qtgui_auto_correlator_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
